<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\LWM_24V.ewp</path>
  </project>
  <batchBuild />
</workspace>
